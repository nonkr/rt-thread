# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, USE_HAL_DRIVER
  c include: .;../../../../rt-thread-v3.1.2/include;board;board/CubeMX_Config/Inc;../libraries/HAL_Drivers;../libraries/HAL_Drivers/config;applications;.;../../../../rt-thread-v3.1.2/libcpu/arm/cortex-m3;../../../../rt-thread-v3.1.2/libcpu/arm/common;../../../../rt-thread-v3.1.2/components/drivers/include;../../../../rt-thread-v3.1.2/components/drivers/include;../../../../rt-thread-v3.1.2/components/drivers/include;../../../../rt-thread-v3.1.2/components/finsh;../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Include;../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Inc;../libraries/STM32F1xx_HAL/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Kernel
    ../../../../rt-thread-v3.1.2/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Applications
    applications/: main.c
  group CORTEX-M3
    ../../../../rt-thread-v3.1.2/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../../rt-thread-v3.1.2/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../../rt-thread-v3.1.2/components/drivers/misc/: pin.c
    ../../../../rt-thread-v3.1.2/components/drivers/serial/: serial.c
    ../../../../rt-thread-v3.1.2/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../rt-thread-v3.1.2/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32_HAL
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
